# Keil uVision project stm.uvproj, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/CMSIS/Include;./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/CMSIS/Device/ST/STM32F10x/Include;./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/STM32F10x_StdPeriph_Driver/src;./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/STM32F10x_StdPeriph_Driver/inc;./STM32_USB-FS-Device_Driver/inc;./STM32_USB-FS-Device_Driver/src;./;./STM32_USB-FS-Device_Lib_V4.1.0/Utilities/STM32_EVAL/STM3210B_EVAL;./STM32_USB-FS-Device_Lib_V4.1.0/Utilities/STM32_EVAL/Common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s
  group user
    ./: main.c stm32f10x_it.c stmTemp.c usart.c
    ./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group peripheral
    ./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
    ./STM32_USB-FS-Device_Lib_V4.1.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
